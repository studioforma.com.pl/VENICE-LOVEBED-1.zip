Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Venice - Lovebed - ver4.ifc
Time: 2025-11-12T16:57:08
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (24)
Name
 | Venice - Lovebed_0 - ObjectType: SketchupGroup
 | Venice - Lovebed_1 - ObjectType: SketchupGroup
 | Venice - Lovebed_2 - ObjectType: SketchupGroup
 | Venice - Lovebed_3 - ObjectType: SketchupGroup
 | Venice - Lovebed_4 - ObjectType: SketchupGroup
 | Venice - Lovebed_5 - ObjectType: SketchupGroup
 | Venice - Lovebed_6 - ObjectType: SketchupGroup
 | Venice - Lovebed_7 - ObjectType: SketchupGroup
 | Venice - Lovebed_8 - ObjectType: SketchupGroup
 | Venice - Lovebed_9 - ObjectType: SketchupGroup
 | Venice - Lovebed_10 - ObjectType: SketchupGroup
 | Venice - Lovebed_11 - ObjectType: SketchupGroup
 | Venice - Lovebed_12 - ObjectType: SketchupGroup
 | Venice - Lovebed_13 - ObjectType: SketchupGroup
 | Venice - Lovebed_14 - ObjectType: SketchupGroup
 | Venice - Lovebed_15 - ObjectType: SketchupGroup
 | Venice - Lovebed_16 - ObjectType: SketchupGroup
 | Venice - Lovebed_17 - ObjectType: SketchupGroup
 | Venice - Lovebed_18 - ObjectType: SketchupGroup
 | Venice - Lovebed_19 - ObjectType: SketchupGroup
 | Venice - Lovebed_20 - ObjectType: SketchupGroup
 | Venice - Lovebed_21 - ObjectType: SketchupGroup
 | Venice - Lovebed_22 - ObjectType: SketchupGroup
 | Venice - Lovebed_23 - ObjectType: SketchupGroup
